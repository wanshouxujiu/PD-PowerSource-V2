# Keil uVision project F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Uesr;..\Uesr\led;..\Uesr\usart;..\Uesr\OLED;..\Uesr\adc;..\Uesr\task;..\Uesr\delay;..\Uesr\GeneralTim;..\Uesr\SC8701;..\Uesr\key;..\Uesr\SIQ02FVS3;..\Uesr\KeyInputFsm;..\Uesr\AT24C02;..\Uesr\iwdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../Uesr/: mian.c stm32f10x_it.c
    ../Uesr/usart/: bsp_usart.c
    ../Uesr/OLED/: bsp_OLED.c
    ../Uesr/adc/: bsp_adc.c
    ../Uesr/task/: task.c
    ../Uesr/delay/: delay.c
    ../Uesr/GeneralTim/: bsp_GeneralTim.c
    ../Uesr/SC8701/: bsp_SC8701.c
    ../Uesr/key/: bsp_key.c
    ../Uesr/SIQ02FVS3/: bsp_SIQ02FVS3.c
    ../Uesr/KeyInputFsm/: KeyInputFsm.c
    ../Uesr/AT24C02/: bsp_i2c_ee.c
    ../Uesr/iwdg/: bsp_iwdg.c
  group DOC
    ../Doc/: readme.txt
